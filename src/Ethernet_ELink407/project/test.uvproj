# Keil uVision project test.uvproj, settings and files
target ethernet (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,HSE_VALUE=8000000
  c include: ..\inc;..\bsp;..\..\STM32_Lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32_Lib\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Third_Party\lwip_v1.3.2\src\include\lwip;..\Third_Party\lwip_v1.3.2\src\include\netif;..\Third_Party\lwip_v1.3.2\src\include\ipv4;..\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Third_Party\lwip_v1.3.2\src\include;..\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\..\STM32_Lib\STM32F4x7_ETH_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../STM32_Lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../STM32_Lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../common/: stm32f4xx_it.c
  group user
    ../user/: fs.c httpd.c httpd_cgi_ssi.c serial_debug.c main.c netconf.c stm32f4x7_eth_bsp.c
  group board
    ../bsp/: delay.c timer.c usart.c
  group periph
    ../../STM32_Lib/STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../STM32_Lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIP
    ../Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
